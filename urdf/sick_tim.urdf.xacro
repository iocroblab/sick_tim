Commit message: added box collider to lidar urdf

File: urdf/sick_tim.urdf.xacro (robot description, xacro)
@@ -41,5 +41,5 @@
       <collision>
         <geometry>
-          <mesh filename="${mesh}" />
+          <box size="0.06 0.06 0.08"/>
         </geometry>
       </collision>
